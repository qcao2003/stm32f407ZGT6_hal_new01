# IAR project rf24l01_stm8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\src; STM8S_StdPeriph_Driver\inc; OLED_SRC
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.srec
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_gpio.c
  group user
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_clk.h stm8s_gpio.h stm8s_spi.h
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_spi.c
  group user/OLED
    OLED_SRC/: delay.c oled.c RF24L01.c spi.c
